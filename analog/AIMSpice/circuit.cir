.include .\lib\p18\p18_models_tt.cir
